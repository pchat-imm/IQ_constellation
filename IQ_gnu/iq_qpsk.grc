options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: iq_QPSK
    output_language: python
    realtime_scheduling: '1'
    title: iq_QPSK
  states: {}

blocks:
- name: CMA_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tiwat/workarea/gnu_radio/IQA_gnu/iq_ff_011024/input_ff/complex_iq_SPEEDTEST_10MS.bin
    repeat: 'True'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '3200e-6'
    freq_offset: '676.859'
    noise_voltage: '0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '62.8e-3'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: CMA_alg
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '62.8e-3'
    max_dev: '1.5'
    osps: '2'
    sps: '4'
    taps: firdes.root_raised_cosine(32, 32, 1.0/float(4), 0.35, 11*4*32)
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    ctrlpanel: 'True'
    samp_per_symbol: '4'
    size: '1024'
    srate: 23.04e6
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 23.04e6
    fc: 3404.64e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 23.04e6
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: out_plot
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out_plot
  states: {}

connections:
- [blocks_file_source_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
